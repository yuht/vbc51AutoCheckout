# Keil uVision project 自动打卡提示.uvproj, settings and files
target 自动提示打卡 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: new +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source
    ./: STARTUP.A51 74hc164.c serial.c 1307_Uart.c timer0.c main.c note
